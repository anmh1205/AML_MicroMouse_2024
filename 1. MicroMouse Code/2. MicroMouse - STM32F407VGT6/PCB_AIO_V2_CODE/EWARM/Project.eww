<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PCB_AIO_V2_CODE.ewp</path>
  </project>
  <batchBuild />
</workspace>
